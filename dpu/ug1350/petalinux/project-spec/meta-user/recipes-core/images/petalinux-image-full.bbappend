#Note: Mention Each package in individual line
#      cascaded representation with line breaks are not valid in this file.
IMAGE_INSTALL_append = " peekpoke"
IMAGE_INSTALL_append = " gpio-demo"
IMAGE_INSTALL_append = " dnndk"
IMAGE_INSTALL_append = " opencv"
IMAGE_INSTALL_append = " dpu"
