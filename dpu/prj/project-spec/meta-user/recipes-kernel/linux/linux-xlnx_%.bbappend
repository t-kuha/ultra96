SRC_URI += "file://user_2019-09-03-17-14-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

