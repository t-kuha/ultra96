SRC_URI += "file://user_2019-07-13-16-05-00.cfg \
            file://user_2019-08-21-05-46-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

