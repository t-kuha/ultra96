SRC_URI += "file://user_2019-01-15-09-45-00.cfg \
            file://user_2019-01-17-10-03-00.cfg \
            file://user_2019-01-17-10-20-00.cfg \
            file://user_2019-01-17-10-40-00.cfg \
            file://user_2019-01-18-10-08-00.cfg \
            file://user_2019-01-18-10-17-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

