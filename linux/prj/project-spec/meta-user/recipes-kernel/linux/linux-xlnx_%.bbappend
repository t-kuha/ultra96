SRC_URI += "file://user_2019-01-24-10-38-00.cfg \
            file://user_2019-01-29-10-34-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

